# Keil uVision project CD.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CD
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Core;.\Common;.\BSP;.\App\App_OLED;.\App\App_KEY;.\App\App_CD;.\App\App_Power
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ./Core/: main.c
  group BSP
    ./BSP/: bsp_gpio.c bsp_rcc.c bsp_iwdg.c bsp_oled_iic.c
  group App
    ./App/App_OLED/: app_oled_task.c
    ./App/App_KEY/: app_key_task.c
    ./App/App_CD/: app_cd_task.c app_cd_fsm.c
    ./App/App_Power/: app_power_task.c
  group Common
    ./Common/: com_type.h com_err.h app_types.h com_config.h
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0
