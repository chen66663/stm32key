# Keil uVision project chezai.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x0000C000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: chezai +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Core;.\BSP;.\Common;.\App\App_KEY;.\App\App_CD;.\App\App_Power;.\App\App_OLED;.\Middleware
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Source Group 1
    ./Core/: main.c
    ./Common/: app_msg.c
  group App_KEY
    ./App/App_KEY/: app_key_task.c
  group App_CD
    ./App/App_CD/: app_cd_task.c app_cd_fsm.c
  group App_Power
    ./App/App_Power/: app_power_task.c
  group App_OLED
    ./App/App_OLED/: app_oled_task.c app_oled_anim.c
  group Drivers/BSP
    ./BSP/: bsp_gpio.c bsp_key.c bsp_iwdg.c bsp_oled_iic.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX 4.82.0, Device:Startup 1.0.0
